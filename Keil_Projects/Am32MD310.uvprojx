# Keil uVision project Am32MD310.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: PY32MD310x8 Puya
  pack: Puya.PY32Mxxx_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MD310 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: PY32MD310x8,FIRST_MD310,USE_FULL_LL_DRIVER
  c include: ..\Mcu\md310\Drivers\CMSIS\Include;..\Mcu\md310\Drivers\CMSIS\Device\PY32MD3xx\Include;..\Mcu\md310\Drivers\PY32MD3xx_HAL_Driver\Inc;..\Mcu\md310\Inc;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../Mcu/md310/Startup/: startup_py32md310xx.s
  group Src
    ../Src/: dshot.c firmwareversion.c functions.c main.c signal.c sounds.c kiss_telemetry.c
  group md310
    ../Mcu/md310/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c py32md3xx_it.c serial_telemetry.c system_py32md3xx.c
  group Drivers
    ../Mcu/md310/Drivers/PY32MD3xx_HAL_Driver/Src/: py32md3xx_ll_adc.c py32md3xx_ll_comp.c py32md3xx_ll_crc.c py32md3xx_ll_dma.c py32md3xx_ll_exti.c py32md3xx_ll_gpio.c py32md3xx_ll_i2c.c py32md3xx_ll_led.c py32md3xx_ll_lptim.c py32md3xx_ll_pwr.c py32md3xx_ll_rcc.c py32md3xx_ll_rtc.c py32md3xx_ll_spi.c py32md3xx_ll_tim.c py32md3xx_ll_usart.c py32md3xx_ll_utils.c
software components: CMSIS:CORE 5.6.0
